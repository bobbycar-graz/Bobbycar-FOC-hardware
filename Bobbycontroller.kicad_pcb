# Repository bobbycar-graz/Bobbycar-FOC-hardware (continued)

## KiCad design Bobbycontroller.kicad_pcb (continued)

Schematic: CAN_TRX.kicad_sch

Parts:
C19, C20: 100nF; C_0603_1608Metric; LCSC C14663
U1: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C38695

Connections:
+3V3: C19.1, U1.5 (VIO); also elsewhere on the board
+5V: C20.1, U1.3 (VCC); also elsewhere on the board
/CAN/CANH: U1.7 (CANH); also elsewhere on the board
/CAN/CANL: U1.6 (CANL); also elsewhere on the board
/CAN/CAN_RX: U1.4 (RXD); also elsewhere on the board
/CAN/CAN_TX: U1.1 (TXD); also elsewhere on the board
GND: C19.2, C20.2, U1.2 (GND), U1.8 (S); also elsewhere on the board

Parts of its further copies:
C91, C92: 100nF; C_0603_1608Metric; LCSC C14663
U19: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C38695

Connections of its further copies:
+3V3: C91.1, U19.5 (VIO); also elsewhere on the board
+5V: C92.1, U19.3 (VCC); also elsewhere on the board
/CAN/CANH: U19.7 (CANH); also elsewhere on the board
/CAN/CANL: U19.6 (CANL); also elsewhere on the board
/ESP32/CAN TRX1/CAN_RX: U19.4 (RXD); also elsewhere on the board
/ESP32/CAN TRX1/CAN_TX: U19.1 (TXD); also elsewhere on the board
GND: C91.2, C92.2, U19.2 (GND), U19.8 (S); also elsewhere on the board

Schematic: hall_conn.kicad_sch

Parts:
C23, C24, C26, C29: 100nF; C_0603_1608Metric; LCSC C14663
D2: 1N4148W; D_SOD-123; LCSC C81598
D5, D7, D9: LED; LED_0603_1608Metric; LCSC C2290
R7, R10, R13, R17, R19, R21: 2.2k; R_0603_1608Metric; LCSC C4190
R23, R26, R28: 3.3k; R_0603_1608Metric; LCSC C22978

Connections:
+3V3: D5.2 (A), D7.2 (A), D9.2 (A), R7.1, R13.1, R19.1; also elsewhere on the board
+5V: D2.2 (A); also elsewhere on the board
/CONNECTORS/Hall_L_1: C24.1, R7.2, R10.2, R23.1; also elsewhere on the board
/CONNECTORS/Hall_L_2: C26.1, R13.2, R17.2, R26.1; also elsewhere on the board
/CONNECTORS/Hall_L_3: C29.1, R19.2, R21.2, R28.1; also elsewhere on the board
/CONNECTORS/Hall_L_VCC: C23.1, D2.1 (K); also elsewhere on the board
/CONNECTORS/L_MTR_HALL_PHA: R28.2; also elsewhere on the board
/CONNECTORS/L_MTR_HALL_PHB: R26.2; also elsewhere on the board
/CONNECTORS/L_MTR_HALL_PHC: R23.2; also elsewhere on the board
GND: C23.2, C24.2, C26.2, C29.2; also elsewhere on the board
unnamed: D5.1 (K), R10.1
unnamed: D7.1 (K), R17.1
unnamed: D9.1 (K), R21.1

Parts of its further copies:
C22, C25, C27, C30: 100nF; C_0603_1608Metric; LCSC C14663
D1: 1N4148W; D_SOD-123; LCSC C81598
D6, D8, D10: LED; LED_0603_1608Metric; LCSC C2290
R8, R11, R14, R18, R20, R22: 2.2k; R_0603_1608Metric; LCSC C4190
R24, R27, R29: 3.3k; R_0603_1608Metric; LCSC C22978

Connections of its further copies:
+3V3: D6.2 (A), D8.2 (A), D10.2 (A), R8.1, R14.1, R20.1; also elsewhere on the board
+5V: D1.2 (A); also elsewhere on the board
/CONNECTORS/Hall_R_1: C25.1, R8.2, R11.2, R24.1; also elsewhere on the board
/CONNECTORS/Hall_R_2: C27.1, R14.2, R18.2, R27.1; also elsewhere on the board
/CONNECTORS/Hall_R_3: C30.1, R20.2, R22.2, R29.1; also elsewhere on the board
/CONNECTORS/Hall_R_VCC: C22.1, D1.1 (K); also elsewhere on the board
/CONNECTORS/R_MTR_HALL_PHA: R24.2; also elsewhere on the board
/CONNECTORS/R_MTR_HALL_PHB: R27.2; also elsewhere on the board
/CONNECTORS/R_MTR_HALL_PHC: R29.2; also elsewhere on the board
GND: C22.2, C25.2, C27.2, C30.2; also elsewhere on the board
unnamed: D6.1 (K), R11.1
unnamed: D8.1 (K), R18.1
unnamed: D10.1 (K), R22.1

Notes on the sheet:
high V_{r}, should protect against short to motor phase

Board: 2 copper layers, 120.0 x 90.0 mm, 328 parts (36 on the bottom side), 166 nets.

File jlcpcb/assembly/BOM-Bobbycontroller.csv:

Comment,Designator,Footprint,LCSC
51V TVS C310059,D39,D_SMC,C10374
470u 25V LKME0901E471MF,"C78,C83,C85",CP_Radial_D10.0mm_P5.00mm_mid,C105289
0.004 2512,"R1,R2,R3,R4",R_2512_6332Metric,C105388
47u LKMD0901K470MF,"C39,C41,C43,C45,C47,C49,C63,C65,C67,C69,C71,C73",CP_Radial_D8.0mm_P3.50mm_mid,C106686
NCE0115K,V7,TO-252-2,C108637
100nF 100V,C76,C_0603_1608Metric,C113803
CDSOD323,D11,D_SOD-323,C127526
100nF,"C19,C20,C21,C22,C23,C24,C25,C26,C27,C28,C29,C30,C32,C33,C34,C35,C36,C37,C50,C51,C52,C53,C54,C55,C56,C60,C74,C77,C79,C81,C82,C84,C88,C89,C90,C91,C92",C_0603_1608Metric,C14663
L7805,U16,TO-263-2,C15077
4.7u,"C57,C86,C87",C_0805_2012Metric,C1779
10k,"R44,R45,R50,R51,R56,R57,R83,R84,R89,R90,R95,R96",R_1206_3216Metric,C17902
4.7,"R109,R46,R47,R52,R53,R58,R59,R76,R85,R86,R91,R92,R97,R98",R_1206_3216Metric,C17937
2A permanent fuse,F1,Fuse_1206_3216Metric,C182310
KEY_SWITCH,J19,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,C20079
1k,"R100,R102,R112,R25,R42,R43,R48,R49,R54,R55,R61,R63,R74,R75,R80,R81,R82,R87,R88,R93,R94",R_0603_1608Metric,C21190
MMBT5551,Q1,SOT-23,C2145
100,"R12,R15,R16,R9",R_0603_1608Metric,C22775
15k,"R110,R111",R_0603_1608Metric,C22809
LED,"D10,D27,D28,D29,D30,D31,D5,D6,D7,D8,D9",LED_0603_1608Metric,C2290
220k,"R105,R106,R34,R35,R66,R67",R_0603_1608Metric,C22961
0R,"R71,R73",R_0603_1608Metric,C22962
3.3k,"R23,R24,R26,R27,R28,R29,R79",R_0603_1608Metric,C22978
Conn_01x05_Male,"HALL_L1,HALL_R1",JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical,C2318
56,"R5,R6",R_0603_1608Metric,C25196
100k,"R36,R37,R77",R_0603_1608Metric,C25803
10k,"R113,R114,R30,R31,R32,R33,R38,R39,R40,R41,R70",R_0603_1608Metric,C25804
1u,"C31,C59,C61",C_0805_2012Metric,C28323
LM75B,"U20,U21",VSSOP-8_3.0x3.0mm_P0.65mm,C2837470
SS36-E3/57T,D13,D_SMC,C35722
220u25V LKMD0901E221MF,"C38,C42,C46,C62,C66,C70",CP_Radial_D8.0mm_P3.50mm_mid,C368593
 UART_L1,"J13,J14,J15,J16",JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,C37815
SRV05-4,"U2,U3",SOT-23-6,C384887
TJA1051T-3,"U1,U19",SOIC-8_3.9x4.9mm_P1.27mm,C38695
"PESD15VL2BT,215",D12,SOT-23,C38838
8MHz 2520,X1,Oscillator_C387448,C390520
Conn_01x04_Male,J17,PinHeader_1x04_P2.54mm_Vertical,C390680
20k,"R101,R103,R104,R60,R62,R64,R65,R78,R99",R_0603_1608Metric,C4184
2.2k,"R10,R107,R108,R11,R13,R14,R17,R18,R19,R20,R21,R22,R68,R69,R7,R72,R8",R_0603_1608Metric,C4190
AMS1117-3.3,U17,SOT-223-3_TabPin2,C426566
LKML1401K221MF,"C11,C14,C3,C6",CP_Radial_D12.5mm_P5.00mm,C443081
Conn_01x06,J20,JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical,C5663
10nF,C58,C_0603_1608Metric,C57112
SM4007,"D22,D23,D24,D25,D35,D36,D37,D38,D47,D48,D49,D50",D_SOD-123,C64898
2.2u 100V,"C75,C80",C_1210_3225Metric,C76685
STM32F103RCT,U10,LQFP-64_10x10mm_P0.5mm,C77940
UCC27712,"U12,U13,U14,U6,U7,U8",SOIC-8_3.9x4.9mm_P1.27mm,C78065
15V C78409,"D14,D41,D42,D43,D44,D45,D46",D_SMB,C78409
1N4148W,"D1,D15,D16,D17,D18,D19,D2,D20,D21,D26,D3,D32,D33,D34,D4",D_SOD-123,C81598
3PEAK TP09-SR,"U15,U4,U5,U9",SOIC-8_3.9x4.9mm_P1.27mm,C81662
B5819W,D40,D_SOD-123,C8598
UCC27517,U11,SOT-23-5,C99395

## Commit log

2020-09-27 Fix MCU NRST connection
2020-09-27 fix some errors
2020-09-27 fix all ERC errors
2020-09-27 Add CAN transceiver
2020-09-27 Do MCU bypassing according to datasheet; annotate
2020-09-27 Add +3.3V reverse current protection diode; add +3.3V on debug header
2020-09-28 Add missing FET driver connection
2020-09-28 initial board layout
2020-09-28 Remove PWR_FLAG from UART header
2020-09-28 Add TVS diode, fuse to 15 V supply
2020-09-28 added footprints, continue layout
2020-09-28 continue analog layout
2020-09-28 continue board layout, placed all components
2020-09-28 layout without hall sensor leds
2020-09-28 finish design
2020-09-28 finish layout
2020-09-28 added TVS diodes on HALL inputs
2020-09-28 add logos
2020-09-28 minor changes
2020-09-29 Minor changes to PCB; convert footprint library to .pretty format, add to project
2020-09-29 modify hall sensor VCC so that overvoltage on one hall sensor will not affect the other motor
2020-09-30 change Mosfet Driver to U3115S
2020-10-02 add silk screen, change diodes at DCDC converters, remove overcurrent detection, add 100nf
2020-10-02 fix silkscreen component references
2020-10-02 fix labels
2020-10-02 round board corners
2020-10-03 added capacitors
2020-10-04 add resistors on mosfet driver inputs, change board corners, fix labels
2020-10-06 prepare production files
2020-10-06 production files
2020-10-18 fix some bugs of the first revision
2020-10-18 Add oscillator for MCU
2020-10-18 Layout oscillator
2021-02-02 Changed dcdc converter to lm5164
2021-02-03 dcdc layout, MOV
    Layout of new dcdc done, MOVs added but not routed
2021-02-03 MOVs placed
2021-02-22 Changed fet driver
2021-02-24 Added FET for LED
2021-03-01 Routed FET and jumper
2021-03-05 added rs232, layout changes
2021-03-09 Added LCSC Part # to most components
2021-03-10 More adaptation to jlcpcb, parts checking
2021-03-11 Added emergency-break connector
2021-03-12 Changed emergency brake to uart2 connector
2021-03-12 Updated production files, added step for coil
2021-03-14 Changed 3 LCSC part numbers
2021-03-14 Added pth caps to assembly
2022-01-23 new 120V DCDC, add hall sensors
2022-02-03 add 0R resistor on BOOT0 against GND
2022-02-15 removed faulty vias and connections
2022-02-15 via change
2022-02-17 Silkscreen and naming fixes
2022-03-05 Updated Current sense circuit
2022-04-02 routed new diodes and opamp
2022-05-04 added esp on bottom side
2022-05-06 Routing tweaks
2022-05-07 Replace CAN VBUS Diode with beefier; misc. routing changes
2022-05-09 Update CAN VBUS diode in schematic
    fixes 4326932b17624209b9845990315cd6ab7ab2b5f4
2022-05-09 Remove *.kicad_prl; update .gitignore
2022-05-09 Refactor stuff adjacent to hall sensor pins
2022-05-09 Update a few library symbols
2022-05-09 Convert symbol library to new format
2022-05-09 Some ERC fixes and other cleanups
2022-05-09 Add some decoupling caps; some more cleanups
2022-05-09 Remove files from old KiCAD version
2022-06-23 ordered this on jlcpcb
2022-08-16 Added pdf
2025-08-09 Updated diodes, added LCSC numbers for all parts
2025-08-09 add image
2025-08-09 update lcsc numbers
2025-08-09 Exchanged more components, DNP and bridge 4.7R resistor, DNP 51V TVS diode
