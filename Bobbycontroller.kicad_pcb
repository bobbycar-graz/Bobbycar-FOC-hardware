# Repository bobbycar-graz/Bobbycar-FOC-hardware

File README.md:

# Bobbycar-FOC-hardware
Our own dual BLDC Motorcontroller

## KiCad design Bobbycontroller.kicad_pcb

Parts:
C1, C2, C4, C5, C7, C8, C9, C10, C12, C13, C15, C16, C17, C18: 2.2u 100V; C_1206_3216Metric; LCSC C577211; not fitted
C3, C6, C11, C14: LKML1401K221MF; CP_Radial_D12.5mm_P5.00mm; LCSC C443080
J1, J2, J3, J4, J5, J6: Conn_01x01_Male; Pin_D1.4mm_L8.5mm_W2.8mm_FlatFork; not fitted
J7: -BATT; MountingHole_2.7mm_M2.5_Pad; not fitted
J8: +BATT; MountingHole_2.7mm_M2.5_Pad; not fitted
J9, J10, J11, J12: Conn_01x01; MountingHole_4mm_Pad_Via; not fitted
LOGO1: Logo_Open_Hardware_Small; not fitted
NT1, NT2: NetTie_2; NetTie-2_SMD_Pad2.0mm; not fitted
R1, R2, R3, R4: 0.004 2512; R_2512_6332Metric; LCSC C46634448

Connections:
+BATT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, J8.1; also elsewhere on the board
-BATT: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, J7.1, NT1.1, NT2.1, R1.2, R2.2, R3.2, R4.2; also elsewhere on the board
/L_MTR_PHA: J1.1; also elsewhere on the board
/R_MTR_PHA: J4.1; also elsewhere on the board
GND: NT1.2, NT2.2; also elsewhere on the board
L_MTR_PHB: J2.1; also elsewhere on the board
L_MTR_PHC: J3.1; also elsewhere on the board
L_MTR_SHUNT: R1.1, R3.1; also elsewhere on the board
R_MTR_PHB: J5.1; also elsewhere on the board
R_MTR_PHC: J6.1; also elsewhere on the board
R_MTR_SHUNT: R2.1, R4.1; also elsewhere on the board

Parts:
C32, C33, C34, C35, C36, C37: 100nF; C_0603_1608Metric; LCSC C14663
D15, D16, D17, D18: 1N4148W; D_SOD-123; LCSC C81598
R30, R31, R32, R33, R38, R39, R40, R41: 10k; R_0603_1608Metric; LCSC C25804
R34, R35: 220k; R_0603_1608Metric; LCSC C22961
R36, R37: 100k; R_0603_1608Metric; LCSC C25803
U4, U5: TLV9362IDR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C4367884

Connections:
+3V3: C36.2, C37.2, D15.1 (K), D16.1 (K), R34.1, R35.1, U4.8 (V+), U5.8 (V+); also elsewhere on the board
-BATT: R31.2, R33.2; also elsewhere on the board
/CURRENT_SENSE/L_MTR_CURR: C34.2, U4.6 (-), U4.7; also elsewhere on the board
/CURRENT_SENSE/R_MTR_CURR: C35.2, U5.6 (-), U5.7; also elsewhere on the board
GND: C32.2, C33.2, C36.1, C37.1, D17.2 (A), D18.2 (A), U4.4 (V-), U5.4 (V-); also elsewhere on the board
L_MTR_SHUNT: R30.2; also elsewhere on the board
unnamed: C34.1, R38.1, R40.2
unnamed: C35.1, R39.1, R41.2
unnamed: D15.2 (A), R30.1, R34.2, U4.3 (+)
unnamed: D16.2 (A), R32.1, R35.2, U5.3 (+)
unnamed: D17.1 (K), R31.1, R36.1, U4.2 (-)
unnamed: D18.1 (K), R33.1, R37.1, U5.2 (-)
unnamed: R36.2, R38.2, U4.1
unnamed: R37.2, R39.2, U5.1
unnamed: C32.1, R40.1, U4.5 (+)
unnamed: C33.1, R41.1, U5.5 (+)
R_MTR_SHUNT: R32.2; also elsewhere on the board

Notes on the sheet:
route sense line directly to shunt insides both for shunt and gnd

Parts:
C75, C80: 2.2u 100V; C_1210_3225Metric; LCSC C76685
C76: 100nF 100V; C_0603_1608Metric; LCSC C113803
C77, C79, C81, C82, C84: 100nF; C_0603_1608Metric; LCSC C14663
C78, C83, C85: 470u 25V LKME0901E471MF; CP_Radial_D10.0mm_P5.00mm_mid; LCSC C105289
D39: 51V TVS C310059; D_SMC; LCSC C10374; not fitted
D40: B5819W; D_SOD-123; LCSC C8598
D41, D42, D43, D44, D45, D46: 15V C78409; D_SMB; LCSC C78409
F1: 2A permanent fuse; Fuse_1206_3216Metric; LCSC C99538
J19: KEY_SWITCH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; LCSC C24192
JP3: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm; not fitted
PS1: 120V DC DC converter; Converter_DCDC_Murata_MEE1SxxxxSC_THT; not fitted
R109: 4.7; R_1206_3216Metric; LCSC C17937; not fitted
R110, R111: 15k; R_0603_1608Metric; LCSC C22809
R112: 1k; R_0603_1608Metric; LCSC C21190
U16: L7805; TO-263-2; LCSC C15077
U17: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C426566

Connections:
+3V3: C84.1, C85.1, U17.2 (VO); also elsewhere on the board
+5V: C78.1, C79.1, D40.2 (A), U16.3 (OUT); also elsewhere on the board
+BATT: J19.1, JP3.2 (B), R110.2; also elsewhere on the board
+VSW: C77.1, C80.1, C81.2, C83.1, D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), PS1.4 (+Vout), U16.1 (IN); also elsewhere on the board
/MCU/V_BATT_MEAS: R111.1, R112.1; also elsewhere on the board
GND: C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.1, C82.2, C83.2, C84.2, C85.2, D39.2 (A), D41.2 (A), D42.2 (A), D43.2 (A), D44.2 (A), D45.2 (A), D46.2 (A), PS1.1 (GND), PS1.3 (GND), R112.2, U16.2 (GND), U17.1 (GND); also elsewhere on the board
KEY_IN: F1.2, J19.2, JP3.1 (A); also elsewhere on the board
unnamed: C75.1, C76.1, D39.1 (K), F1.1, PS1.2 (+Vin), R109.1, R109.2
unnamed: C82.1, D40.1 (K), U17.3 (VI)
unnamed: R110.1, R111.2

Notes on the sheet:
beefy

Parts:
C28: 100nF; C_0603_1608Metric; LCSC C14663
C31: 1u; C_0805_2012Metric; LCSC C28323
D3, D4: 1N4148W; D_SOD-123; LCSC C81598
D11: 3.3V TVS; D_SOD-323; LCSC C314254
D12: PESD15VL2BT,215; SOT-23; LCSC C38838
D13: SS36-E3/57T; D_SMC; LCSC C35722
D14: 15V C78409; D_SMB; LCSC C78409
HALL_L1: Conn_01x05_Male; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical; LCSC C57142
HALL_R1: Conn_01x05_Male; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical; LCSC C57142
J13: UART_L1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical; LCSC C192885
J14: UART_R1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical; LCSC C192885
J15, J16: CAN BUS JST XH 4P; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical; LCSC C68117
J17: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical; LCSC C2691448
R9, R12, R15, R16: 100; R_0603_1608Metric; LCSC C22775
R25: 1k; R_0603_1608Metric; LCSC C21190
U2, U3: SRV05-4; SOT-23-6; LCSC C384887

Connections:
+3V3: J17.4, R25.1; also elsewhere on the board
+VSW: D3.2 (A), D4.2 (A), D13.2 (A); also elsewhere on the board
/CAN/CANH: D12.1 (A1), J15.4, J16.4; also elsewhere on the board
/CAN/CANL: D12.2 (A2), J15.3, J16.3; also elsewhere on the board
/CONNECTORS/Hall_L_1: HALL_L1.2, U2.1 (IO1); also elsewhere on the board
/CONNECTORS/Hall_L_2: HALL_L1.3, U2.4 (IO3); also elsewhere on the board
/CONNECTORS/Hall_L_3: HALL_L1.4, U2.6 (IO4); also elsewhere on the board
/CONNECTORS/Hall_L_VCC: HALL_L1.5, U2.5 (VP); also elsewhere on the board
/CONNECTORS/Hall_R_1: HALL_R1.4, U3.4 (IO3); also elsewhere on the board
/CONNECTORS/Hall_R_2: HALL_R1.3, U3.6 (IO4); also elsewhere on the board
/CONNECTORS/Hall_R_3: HALL_R1.2, U3.1 (IO1); also elsewhere on the board
/CONNECTORS/Hall_R_VCC: HALL_R1.5, U3.5 (VP); also elsewhere on the board
/CONNECTORS/MCU_SWCLK: J17.3; also elsewhere on the board
/CONNECTORS/MCU_SWDIO: J17.1; also elsewhere on the board
/CONNECTORS/UART_R_RX: C28.1, D11.1 (A1), R15.1, R25.2; also elsewhere on the board
/CONNECTORS/UART_R_TX: R9.1; also elsewhere on the board
GND: C28.2, C31.2, D11.2 (A2), D12.3 (common), D14.2 (A), HALL_L1.1, HALL_R1.1, J13.1, J14.1, J15.1, J16.1, J17.2, U2.2 (VN), U3.2 (VN); also elsewhere on the board
unnamed: D3.1 (K), J13.4
unnamed: D4.1 (K), J14.4
unnamed: C31.1, D13.1 (K), D14.1 (K), J15.2, J16.2
unnamed: J13.2, R16.2
unnamed: J13.3, R12.2
unnamed: J14.2, R15.2
unnamed: J14.3, R9.2
U1_RX: R16.1; also elsewhere on the board
U1_TX: R12.1; also elsewhere on the board

Notes on the sheet:
TVS diodes
CANL
CANH
CAN_GND
VBUS

Parts:
C51, C52, C53, C54, C55, C56, C60: 100nF; C_0603_1608Metric; LCSC C14663
C57: 4.7u; C_0805_2012Metric; LCSC C1779
C58: 10nF; C_0603_1608Metric; LCSC C57112
C59, C61: 1u; C_0805_2012Metric; LCSC C28323
D26: 1N4148W; D_SOD-123; LCSC C81598
D27, D28, D29, D30, D31: LED; LED_0603_1608Metric; LCSC C2290
J18: Conn_01x01_Male; Pin_D1.4mm_L8.5mm_W2.8mm_FlatFork; not fitted
LS1: FS1212; Buzzer_12x9.5RM7.6; LCSC C482353
Q1: MMBT5551; SOT-23; LCSC C2145
R70: 10k; R_0603_1608Metric; LCSC C25804
R71: 0R; R_0603_1608Metric; LCSC C22962
R72: 2.2k; R_0603_1608Metric; LCSC C4190
R73: 220; R_0603_1608Metric; LCSC C22962
R74, R75, R80: 1k; R_0603_1608Metric; LCSC C21190
R76: 4.7; R_1206_3216Metric; LCSC C17937
R77: 100k; R_0603_1608Metric; LCSC C25803
R78: 20k; R_0603_1608Metric; LCSC C4184
R79: 3.3k; R_0603_1608Metric; LCSC C22978
U10: STM32F103RCT; LQFP-64_10x10mm_P0.5mm; LCSC C8323
U11: UCC27517; SOT-23-5; LCSC C99395
V7: NCE0115K; TO-252-2; LCSC C108637
X1: 8MHz 2520; Oscillator_C387448; LCSC C390520

Connections:
+3V3: C51.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, R70.1, R74.2, R80.1, U10.1 (VBAT), U10.13 (VDDA), U10.19 (VDD), U10.32 (VDD), U10.48 (VDD), U10.64 (VDD), X1.1 (Standby), X1.4 (VDD); also elsewhere on the board
+5V: R79.1; also elsewhere on the board
+VSW: C60.1, C61.1, D26.1 (K), LS1.1, R78.1, U11.1 (VDD); also elsewhere on the board
/CAN/CAN_RX: U10.61 (PB8); also elsewhere on the board
/CAN/CAN_TX: U10.62 (PB9); also elsewhere on the board
/CONNECTORS/L_MTR_HALL_PHA: U10.57 (PB5); also elsewhere on the board
/CONNECTORS/L_MTR_HALL_PHB: U10.58 (PB6); also elsewhere on the board
/CONNECTORS/L_MTR_HALL_PHC: U10.59 (PB7); also elsewhere on the board
/CONNECTORS/MCU_SWCLK: U10.49 (PA14); also elsewhere on the board
/CONNECTORS/MCU_SWDIO: U10.46 (PA13); also elsewhere on the board
/CONNECTORS/R_MTR_HALL_PHA: U10.53 (PC12); also elsewhere on the board
/CONNECTORS/R_MTR_HALL_PHB: U10.52 (PC11); also elsewhere on the board
/CONNECTORS/R_MTR_HALL_PHC: U10.51 (PC10); also elsewhere on the board
/CONNECTORS/UART_R_RX: U10.30 (PB11); also elsewhere on the board
/CONNECTORS/UART_R_TX: U10.29 (PB10); also elsewhere on the board
/CURRENT_SENSE/L_MTR_CURR: U10.9 (PC1); also elsewhere on the board
/CURRENT_SENSE/R_MTR_CURR: U10.8 (PC0); also elsewhere on the board
/L_MTR_PHA/H_BRIDGE_HI: U10.41 (PA8); also elsewhere on the board
/L_MTR_PHA/H_BRIDGE_LO: U10.34 (PB13); also elsewhere on the board
/L_MTR_PHB/H_BRIDGE_HI: U10.42 (PA9); also elsewhere on the board
/L_MTR_PHB/H_BRIDGE_LO: U10.35 (PB14); also elsewhere on the board
/L_MTR_PHC/H_BRIDGE_HI: U10.43 (PA10); also elsewhere on the board
/L_MTR_PHC/H_BRIDGE_LO: U10.36 (PB15); also elsewhere on the board
/L_MTR_PH_SENSE/PH_AMP_A_OUT: U10.25 (PC5); also elsewhere on the board
/L_MTR_PH_SENSE/PH_AMP_B_OUT: U10.24 (PC4); also elsewhere on the board
/MCU/AIN_V_BATT: U10.15 (PA1)
/MCU/L_MTR_OVERCUR: U10.44 (PA11)
/MCU/R_MTR_OVERCUR: U10.22 (PA6)
/MCU/R_MTR_PHA_HI: U10.37 (PC6); also elsewhere on the board
/MCU/R_MTR_PHA_LO: U10.23 (PA7); also elsewhere on the board
/MCU/R_MTR_PHA_SENSE: U10.14 (PA0); also elsewhere on the board
/MCU/R_MTR_PHB_HI: U10.38 (PC7); also elsewhere on the board
/MCU/R_MTR_PHB_LO: U10.26 (PB0); also elsewhere on the board
/MCU/R_MTR_PHB_SENSE: U10.11 (PC3); also elsewhere on the board
/MCU/R_MTR_PHC_HI: U10.39 (PC8); also elsewhere on the board
/MCU/R_MTR_PHC_LO: U10.27 (PB1); also elsewhere on the board
/MCU/SUPPLY_EN_MCU: U10.21 (PA5)
/MCU/V_BATT_MEAS: U10.10 (PC2); also elsewhere on the board
GND: C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), Q1.3 (E), R71.2, R75.2, U10.12 (VSSA), U10.18 (VSS), U10.31 (VSS), U10.47 (VSS), U10.63 (VSS), U11.2 (GND), U11.4 (IN-), V7.3 (S), X1.2 (GND); also elsewhere on the board
KEY_IN: R77.1; also elsewhere on the board
unnamed: D26.2 (A), LS1.2, Q1.2 (C)
unnamed: D27.2 (A), R72.2
unnamed: D28.2 (A), R77.2
unnamed: D29.2 (A), R78.2
unnamed: D30.2 (A), R79.2
unnamed: D31.2 (A), R80.2
unnamed: J18.1, V7.2 (D)
unnamed: Q1.1 (B), R73.1
unnamed: R71.1, U10.60 (BOOT0)
unnamed: C52.1, R70.2, U10.7 (NRST)
unnamed: R73.2, U10.20 (PA4)
unnamed: R72.1, U10.28 (PB2)
unnamed: U10.55 (PB3), U11.3 (IN+)
unnamed: R74.1, R75.1, U10.33 (PB12)
unnamed: U10.5 (PD0), X1.3 (Out)
unnamed: R76.2, U11.5 (OUT)
unnamed: R76.1, V7.1 (G)
U1_RX: U10.17 (PA3); also elsewhere on the board
U1_TX: U10.16 (PA2); also elsewhere on the board

Notes on the sheet:
ID for CAN Address
LED-Light

Parts:
C38: 220u25V; CP_Radial_D8.0mm_P3.50mm_mid; LCSC C106697
C39, C41: 47u LKMD0901K470MF; CP_Radial_D8.0mm_P3.50mm_mid; LCSC C106686
C40: 2.2u 100V; C_1206_3216Metric; LCSC C577211
D19: 1N4148W; D_SOD-123; LCSC C81598
R42, R43: 1k; R_0603_1608Metric; LCSC C21190
R44, R45: 10k; R_1206_3216Metric; LCSC C17902
R46, R47: 4.7; R_1206_3216Metric; LCSC C17937
RV1: V20P35P; MOV20; LCSC C1528974
U6: IRS2304; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C82060
V1, V2: CRSS042N10N; TO-263-2; LCSC C410926

Connections:
+BATT: C40.1, C41.1, RV1.1, V1.2 (D); also elsewhere on the board
+VSW: C38.1, D19.2 (A), U6.3 (VCC); also elsewhere on the board
/L_MTR_PHA: C39.2, R44.1, U6.6 (VS), V1.3 (S), V2.2 (D); also elsewhere on the board
/L_MTR_PHA/H_BRIDGE_HI: R42.2; also elsewhere on the board
/L_MTR_PHA/H_BRIDGE_LO: R43.2; also elsewhere on the board
GND: C38.2, U6.4 (COM); also elsewhere on the board
L_MTR_SHUNT: C40.2, C41.2, R45.1, RV1.2, V2.3 (S); also elsewhere on the board
unnamed: C39.1, D19.1 (K), U6.8 (VB)
unnamed: R42.1, U6.2 (HIN)
unnamed: R44.2, R46.2, U6.7 (HO)
unnamed: R43.1, U6.1 (LIN)
unnamed: R45.2, R47.2, U6.5 (LO)
unnamed: R46.1, V1.1 (G)
unnamed: R47.1, V2.1 (G)

Parts of its further copies:
C42, C46, C62, C66, C70: 220u25V; CP_Radial_D8.0mm_P3.50mm_mid; LCSC C106697
C43, C45, C47, C49, C63, C65, C67, C69, C71, C73: 47u LKMD0901K470MF; CP_Radial_D8.0mm_P3.50mm_mid; LCSC C106686
C44, C48, C64, C68, C72: 2.2u 100V; C_1206_3216Metric; LCSC C577211
D20, D21, D32, D33, D34: 1N4148W; D_SOD-123; LCSC C81598
R48, R49, R54, R55, R81, R82, R87, R88, R93, R94: 1k; R_0603_1608Metric; LCSC C21190
R50, R51, R56, R57, R83, R84, R89, R90, R95, R96: 10k; R_1206_3216Metric; LCSC C17902
R52, R53, R58, R59, R85, R86, R91, R92, R97, R98: 4.7; R_1206_3216Metric; LCSC C17937
RV2, RV3, RV4, RV5, RV6: V20P35P; MOV20; LCSC C1528974
U7, U8, U12, U13, U14: IRS2304; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C82060
V3, V4, V5, V6, V8, V9, V10, V11, V12, V13: CRSS042N10N; TO-263-2; LCSC C410926

Connections of its further copies:
+BATT: C44.1, C45.1, C48.1, C49.1, C64.1, C65.1, C68.1, C69.1, C72.1, C73.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, V3.2 (D), V5.2 (D), V8.2 (D), V10.2 (D), V12.2 (D); also elsewhere on the board
+VSW: C42.1, C46.1, C62.1, C66.1, C70.1, D20.2 (A), D21.2 (A), D32.2 (A), D33.2 (A), D34.2 (A), U7.3 (VCC), U8.3 (VCC), U12.3 (VCC), U13.3 (VCC), U14.3 (VCC); also elsewhere on the board
/L_MTR_PHB/H_BRIDGE_HI: R48.2; also elsewhere on the board
/L_MTR_PHB/H_BRIDGE_LO: R49.2; also elsewhere on the board
/L_MTR_PHC/H_BRIDGE_HI: R54.2; also elsewhere on the board
/L_MTR_PHC/H_BRIDGE_LO: R55.2; also elsewhere on the board
/MCU/R_MTR_PHA_HI: R81.2; also elsewhere on the board
/MCU/R_MTR_PHA_LO: R82.2; also elsewhere on the board
/MCU/R_MTR_PHB_HI: R87.2; also elsewhere on the board
/MCU/R_MTR_PHB_LO: R88.2; also elsewhere on the board
/MCU/R_MTR_PHC_HI: R93.2; also elsewhere on the board
/MCU/R_MTR_PHC_LO: R94.2; also elsewhere on the board
/R_MTR_PHA: C63.2, R83.1, U12.6 (VS), V8.3 (S), V9.2 (D); also elsewhere on the board
GND: C42.2, C46.2, C62.2, C66.2, C70.2, U7.4 (COM), U8.4 (COM), U12.4 (COM), U13.4 (COM), U14.4 (COM); also elsewhere on the board
L_MTR_PHB: C43.2, R50.1, U7.6 (VS), V3.3 (S), V4.2 (D); also elsewhere on the board
L_MTR_PHC: C47.2, R56.1, U8.6 (VS), V5.3 (S), V6.2 (D); also elsewhere on the board
L_MTR_SHUNT: C44.2, C45.2, C48.2, C49.2, R51.1, R57.1, RV2.2, RV3.2, V4.3 (S), V6.3 (S); also elsewhere on the board
unnamed: C43.1, D20.1 (K), U7.8 (VB)
unnamed: C47.1, D21.1 (K), U8.8 (VB)
unnamed: C63.1, D32.1 (K), U12.8 (VB)
unnamed: C67.1, D33.1 (K), U13.8 (VB)
unnamed: C71.1, D34.1 (K), U14.8 (VB)
unnamed: R48.1, U7.2 (HIN)
unnamed: R50.2, R52.2, U7.7 (HO)
unnamed: R49.1, U7.1 (LIN)
unnamed: R51.2, R53.2, U7.5 (LO)
unnamed: R54.1, U8.2 (HIN)
unnamed: R56.2, R58.2, U8.7 (HO)
unnamed: R55.1, U8.1 (LIN)
unnamed: R57.2, R59.2, U8.5 (LO)
unnamed: R81.1, U12.2 (HIN)
unnamed: R83.2, R85.2, U12.7 (HO)
unnamed: R82.1, U12.1 (LIN)
unnamed: R84.2, R86.2, U12.5 (LO)
unnamed: R87.1, U13.2 (HIN)
unnamed: R89.2, R91.2, U13.7 (HO)
unnamed: R88.1, U13.1 (LIN)
unnamed: R90.2, R92.2, U13.5 (LO)
unnamed: R93.1, U14.2 (HIN)
unnamed: R95.2, R97.2, U14.7 (HO)
unnamed: R94.1, U14.1 (LIN)
unnamed: R96.2, R98.2, U14.5 (LO)
unnamed: R52.1, V3.1 (G)
unnamed: R53.1, V4.1 (G)
unnamed: R58.1, V5.1 (G)
unnamed: R59.1, V6.1 (G)
unnamed: R85.1, V8.1 (G)
unnamed: R86.1, V9.1 (G)
unnamed: R91.1, V10.1 (G)
unnamed: R92.1, V11.1 (G)
unnamed: R97.1, V12.1 (G)
unnamed: R98.1, V13.1 (G)
R_MTR_PHB: C67.2, R89.1, U13.6 (VS), V10.3 (S), V11.2 (D); also elsewhere on the board
R_MTR_PHC: C71.2, R95.1, U14.6 (VS), V12.3 (S), V13.2 (D); also elsewhere on the board
R_MTR_SHUNT: C64.2, C65.2, C68.2, C69.2, C72.2, C73.2, R84.1, R90.1, R96.1, RV4.2, RV5.2, RV6.2, V9.3 (S), V11.3 (S), V13.3 (S); also elsewhere on the board

Parts:
C50: 100nF; C_0603_1608Metric; LCSC C14663
D22, D23, D24, D25, D47, D48: 1N4148W; D_SOD-123; LCSC C81598
R60, R62, R64, R65: 20k; R_0603_1608Metric; LCSC C4184
R61, R63: 1k; R_0603_1608Metric; LCSC C21190
R66, R67: 220k; R_0603_1608Metric; LCSC C22961
R68, R69: 2.2k; R_0603_1608Metric; LCSC C4190
U9: TLV9362IDR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C4367884

Connections:
+3V3: C50.1, R66.2, R67.2, U9.8 (V+); also elsewhere on the board
/L_MTR_PH_SENSE/PH_AMP_A_OUT: R68.1, U9.1; also elsewhere on the board
/L_MTR_PH_SENSE/PH_AMP_B_OUT: R69.1, U9.7; also elsewhere on the board
GND: C50.2, D23.2 (A), D25.2 (A), D47.2 (A), D48.2 (A), U9.4 (V-); also elsewhere on the board
L_MTR_PHB: R62.1; also elsewhere on the board
L_MTR_PHC: R60.1; also elsewhere on the board
L_MTR_SHUNT: R61.1, R63.1; also elsewhere on the board
unnamed: D22.2 (A), D47.1 (K), R64.2, R66.1, U9.3 (+)
unnamed: D22.1 (K), D23.1 (K), R61.2, R68.2, U9.2 (-)
unnamed: D24.2 (A), D48.1 (K), R65.2, R67.1, U9.5 (+)
unnamed: D24.1 (K), D25.1 (K), R63.2, R69.2, U9.6 (-)
unnamed: R60.2, R64.1
unnamed: R62.2, R65.1

Parts of its further copies:
C74: 100nF; C_0603_1608Metric; LCSC C14663
D35, D36, D37, D38, D49, D50: 1N4148W; D_SOD-123; LCSC C81598
R99, R101, R103, R104: 20k; R_0603_1608Metric; LCSC C4184
R100, R102: 1k; R_0603_1608Metric; LCSC C21190
R105, R106: 220k; R_0603_1608Metric; LCSC C22961
R107, R108: 2.2k; R_0603_1608Metric; LCSC C4190
U15: TLV9362IDR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C4367884

Connections of its further copies:
+3V3: C74.1, R105.2, R106.2, U15.8 (V+); also elsewhere on the board
/MCU/R_MTR_PHA_SENSE: R107.1, U15.1; also elsewhere on the board
/MCU/R_MTR_PHB_SENSE: R108.1, U15.7; also elsewhere on the board
GND: C74.2, D36.2 (A), D38.2 (A), D49.2 (A), D50.2 (A), U15.4 (V-); also elsewhere on the board
unnamed: D35.2 (A), D49.1 (K), R103.2, R105.1, U15.3 (+)
unnamed: D35.1 (K), D36.1 (K), R100.2, R107.2, U15.2 (-)
unnamed: D37.2 (A), D50.1 (K), R104.2, R106.1, U15.5 (+)
unnamed: D37.1 (K), D38.1 (K), R102.2, R108.2, U15.6 (-)
unnamed: R101.2, R104.1
unnamed: R99.2, R103.1
R_MTR_PHB: R101.1; also elsewhere on the board
R_MTR_PHC: R99.1; also elsewhere on the board
R_MTR_SHUNT: R100.1, R102.1; also elsewhere on the board

Parts:
C86, C87: 4.7u; C_0805_2012Metric; LCSC C1779
C88, C89, C90: 100nF; C_0603_1608Metric; LCSC C14663
J20: Conn_01x06; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical; not fitted
R113, R114: 10k; R_0603_1608Metric; LCSC C25804
U18: ESP32-WROOM-32; LCSC C701343; not fitted
U20, U21: LM75BDP; VSSOP-8_3.0x3.0mm_P0.65mm; LCSC C33099

Connections:
+3V3: C86.1, C87.1, C88.1, C89.2, C90.2, R113.1, R114.1, U18.2 (VDD), U20.8 (+Vs), U21.7 (A0), U21.8 (+Vs); also elsewhere on the board
+5V: J20.6; also elsewhere on the board
/ESP32/CAN TRX1/CAN_RX: U18.36 (IO22); also elsewhere on the board
/ESP32/CAN TRX1/CAN_TX: U18.33 (IO21); also elsewhere on the board
/ESP32/ESP_EN: J20.4, R113.2, U18.3 (EN)
/ESP32/ESP_IO0: J20.5, R114.2, U18.25 (IO0)
/ESP32/ESP_RX: J20.2, U18.34 (RXD0/IO3)
/ESP32/ESP_TX: J20.3, U18.35 (TXD0/IO1)
/ESP32/SCL: U18.31 (IO19), U20.2 (SCL), U21.2 (SCL)
/ESP32/SDA: U18.30 (IO18), U20.1 (SDA), U21.1 (SDA)
GND: C86.2, C87.2, C88.2, C89.1, C90.1, J20.1, U18.1 (GND), U18.15 (GND), U18.38 (GND), U18.39 (GND), U20.4 (GND), U20.5 (A2), U20.6 (A1), U20.7 (A0), U21.4 (GND), U21.5 (A2), U21.6 (A1); also elsewhere on the board
U1_RX: U18.26 (IO4); also elsewhere on the board
U1_TX: U18.24 (IO2); also elsewhere on the board

Schematic: can_termination.kicad_sch

Parts:
C21: 100nF; C_0603_1608Metric; LCSC C14663
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm; not fitted
R5, R6: 56; R_0603_1608Metric; LCSC C25196

Connections:
/CAN/CANH: JP1.1 (A); also elsewhere on the board
/CAN/CANL: JP2.2 (B); also elsewhere on the board
GND: C21.2; also elsewhere on the board
unnamed: C21.1, R5.2, R6.1
unnamed: JP1.2 (B), R5.1
unnamed: JP2.1 (A), R6.2
